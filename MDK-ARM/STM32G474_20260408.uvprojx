# Keil uVision project STM32G474_20260408.uvprojx, settings and files
target foc_Sensorless_echokoen (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G474_20260408 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Config;../App;../Control/Common;../Control/Model;../Control/Sensing;../Control/Modulation;../Control/Loop;../Control/Startup;../Control/Observer;../Control/Safety;../Control/Trace;../Drivers/BSP;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Middlewares/FreeRTOS/include;../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_stm32g474xx.s
  group Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c system_stm32g4xx.c
    ../Core/Inc/: main.h stm32g4xx_it.h stm32g4xx_hal_conf.h FreeRTOSConfig.h
  group Config
    ../Config/: foc_config.h
  group BSP
    ../Drivers/BSP/: bsp_adc.c bsp_adc.h bsp_tim.c bsp_tim.h bsp_usart.c bsp_usart.h bsp_gpio.c bsp_gpio.h bsp_dma.c bsp_dma.h bsp_key.c bsp_key.h bsp_dac.c bsp_dac.h bsp_cordic.c bsp_cordic.h
  group App
    ../App/: app_foc.c app_foc.h app_foc_timing.c app_foc_timing.h app_debug.c app_debug.h app_rtos.c app_rtos.h
  group MotorControl
    ../Control/Common/: foc_types.h foc_math.c foc_math.h
    ../Control/Sensing/: foc_current_sense.c foc_current_sense.h
    ../Control/Modulation/: foc_svpwm.c foc_svpwm.h foc_deadtime_comp.c foc_deadtime_comp.h
    ../Control/Loop/: foc_current_loop.c foc_current_loop.h foc_speed_loop.c foc_speed_loop.h
    ../Control/Startup/: foc_startup.c foc_startup.h foc_handover.c foc_handover.h
    ../Control/Observer/: foc_observer.c foc_observer.h
    ../Control/Safety/: foc_protection.c foc_protection.h
  group MotorModel
    ../Control/Model/: foc_clarke_park.c foc_clarke_park.h foc_pi_controller.c foc_pi_controller.h foc_flux_observer_pll.c foc_flux_observer_pll.h
  group Diagnostics
    ../Control/Trace/: foc_trace.c foc_trace.h
  group FreeRTOS
    ../Middlewares/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group ST_HAL
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group CMSIS
    ../Drivers/CMSIS/Include/: core_cm4.h
    ../Drivers/CMSIS/Device/ST/STM32G4xx/Include/: stm32g474xx.h stm32g4xx.h system_stm32g4xx.h
software components: CMSIS:CORE 4.3.0
