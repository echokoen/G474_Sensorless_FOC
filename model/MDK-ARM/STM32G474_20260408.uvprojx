# Keil uVision project STM32G474_20260408.uvprojx, settings and files
target foc_Sensorless_echokoen (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G474_20260408 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/BSP;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\App;..\Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application
    ../Core/Inc/: foc_config.h
    ../Core/Inc/PMSM_Control_Core/: FluxObserver_PLL.h Clarke_Park.h PI_Controller.h
    ../Core/Src/PMSM_Control_Core/: FluxObserver_PLL.c Clarke_Park.c PI_Controller.c
  group App
    ../App/: app_foc.h app_foc.c app_debug.h app_debug.c
  group Control
    ../Control/: foc_types.h foc_math.h foc_sampling.h foc_sampling.c foc_pwm.h foc_pwm.c foc_current_loop.h foc_current_loop.c foc_openloop.h foc_openloop.c foc_observer.h foc_observer.c foc_switchover.h foc_switchover.c foc_protection.h foc_protection.c foc_debug.h foc_debug.c foc_deadtime.c foc_deadtime.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/BSP
    ../Drivers/BSP/: bsp_usart.c bsp_tim.c bsp_dma.c bsp_key.c bsp_dac.c bsp_cordic.c bsp_adc.c bsp_gpio.c
software components: CMSIS:CORE 4.3.0
